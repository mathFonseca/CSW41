# Keil uVision project IncludeBinFile.uvprojx, settings and files
target Cortex-M3 Simulation (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: IncludeBinFile
  BeforeMake: SRecord\srec_cat.exe @@MyBinFile2ConvCmd
  c flags: Optim=1 OneElfS=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c MyBinFile1.s MyBinFile2.c MyBinFile2ConvCmd
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
